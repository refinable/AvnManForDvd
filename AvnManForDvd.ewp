# IAR project AvnManForDvd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STM3210C_EVAL; USE_STDPERIPH_DRIVER; STM32F10X_CAN; STM32F10X_CL25
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\STM32F10x_Can_Driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AvnManForDvd.bin
  ILINK.IlinkOutputFile: AvnManForDvd.out
  ILINK.IlinkIcfFile: stm32f105xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: MALIBU7.hex
  ILINK.IlinkOutputFile: MALIBU7.out
  group CMSIS/CM3/CoreSupport
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../Libraries/CMSIS/CM3/DeviceSupport/STM32F10x/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group Ewarm_iar
    ../../Libraries/CMSIS/CM3/DeviceSupport/STM32F10x/startup_iar/: startup_stm32f10x_cl.s
  group STM32F10x_Driver/inc
    ../../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_Driver/src
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Work
    ./: AvnMan.a main.c monitor.c
